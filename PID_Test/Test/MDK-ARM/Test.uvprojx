# Keil uVision project Test.uvprojx, settings and files
target Test (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../application;../algorithm;../bsp/boards;../Config
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group algorithm
    ../algorithm/: PID.c PID.h
  group applications
    ../application/: CAN_receive.c CAN_receive.h CAN_send.c CAN_send.h struct_typedef.h ZeroCheck.c ZeroCheck.h
  group config
    ../Config/: can_config.h
  group bsp
    ../bsp/boards/: bsp_can.c bsp_can.h
software components: CMSIS:CORE 4.3.0
